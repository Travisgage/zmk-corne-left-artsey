## config/boards/shields/corne_left_3row/Kconfig.shield
```kconfig
config SHIELD_CORNE_LEFT_3ROW
    bool "Corne Left (3-row matrix)"
    depends on BOARD_NICE_NANO
```
